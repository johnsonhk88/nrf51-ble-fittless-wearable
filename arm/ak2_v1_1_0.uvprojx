# Keil uVision project ak2_v1_1_0.uvprojx, settings and files
target ak2_v1_1_0 (ARM-ADS)
  device: nRF51822_xxAA Nordic Semiconductor
  pack: NordicSemiconductor.nRF_DeviceFamilyPack.8.6.0
  cpu: IROM(0x00000000,0x40000) IRAM(0x20000000,0x4000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: ak2_v1_1_0 +hex
  c flags: Optim=4
  c define: NRF51 DEBUG_NRF_USER  SETUPA  BOARD_AKII  BLE_STACK_SUPPORT_REQD
  c misc: --c99
  c include: ..\Include;..\user;..\Include\app_common;..\Include\ble;..\Include\ble\ble_services;..\Include\s110;..\Include\boards;..\Include\sd_common
  library: MicroLIB
  memory RVCT4: ROM 0x14000 size 0x2c000
  memory RVCT9: RAM 0x20002000 size 0x2000
  group startup
    ../Source/templates/: system_nrf51.c
    ../Source/templates/arm/: arm_startup_nrf51.s
  group BLE_Service
    ../Source/ble/ble_services/: ble_srv_common.c
    ../user/: ble_nus.c
  group BLE Library
    ../Source/ble/: ble_advdata.c ble_conn_params.c ble_flash.c
    ../Source/sd_common/: softdevice_handler.c
  group Library
    ../Source/nrf_delay/: nrf_delay.c
    ../Source/simple_uart/: simple_uart.c
    ../Source/app_common/: app_timer.c app_button.c app_gpiote.c
  group source code
    ../user/: main.c adc_apps.c ble_proximity.c ble_apps_uart.c
  group Timer
    ../user/: timer.c
  group SPI
    ../Source/spi_master/: spi_master.c
  group LED driver
    ../user/: led.c
  group OLED
    ../user/: oled_096.c
  group key
    ../user/: key.c
  group UART Debug
    ../user/: uart.c retarget.c
  group RTC
    ../user/: rtc.c
  group Heart Beat sensor
    ../user/: adc_heart_rate.c
